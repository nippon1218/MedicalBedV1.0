# Keil uVision project HAL_ESP8266_429.uvprojx, settings and files
target HAL_ESP8266_429 (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HAL_ESP8266_429 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CORE;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\W25QXX;..\MALLOC;..\USMART;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\ATK_ESP8266;..\HARDWARE\PWM;..\HARDWARE\MOTOR;..\HARDWARE\FUNCTION;..\HARDWARE\ADC;..\HARDWARE\PCF8574;..\HARDWARE\DS18B20;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\UCOS-BSP;..\UCOSIII\UCOS-CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE\CHECK;..\MODBUS_MASTER;..\HARDWARE\NAND;..\HARDWARE\PUMP;..\HARDWARE\HX711;E:\MDK5\ARM\ARMCC\include;..\HARDWARE\VK3214;D:\anzhuangruanjian\KEIL5\ARM\ARMCC;..\HARDWARE\MOTOR;..\HARDWARE\CHECK;..\SYSTEM\sys;D:\anzhuangruanjian\KEIL5\ARM\ARMCC\include;..\HARDWARE\HANG;..\HARDWARE\WASHLET;..\HARDWARE\RESET;..\HARDWARE\MAINJUDGE;..\HARDWARE\BACKLEG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/WASHLET/: washlet.c
    ../HARDWARE/FUNCTION/: function.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/NAND/: nand.c
    ../HARDWARE/PUMP/: pump.c
    ../HARDWARE/HX711/: hx711.c
    ../HARDWARE/CHECK/: check.c
    ../HARDWARE/HANG/: Hang.c
    ../HARDWARE/RESET/: reset.c
    ../HARDWARE/MAINJUDGE/: mainjudge.c
    ../HARDWARE/BACKLEG/: backleg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group ATK_ESP8266
    ../ATK_ESP8266/: common.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS-BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/UCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group MODBUS_MASTER
    ../MODBUS_MASTER/: bsp_user_lib.c modbus_master.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c readme.txt
